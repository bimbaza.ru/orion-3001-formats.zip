Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: /dev/null
Time: 2026-09-22T14:18:46+00:00
Written by: IfcOpenShell 0.8.5
Made in: IfcOpenShell 0.8.5
Authorization: Nobody

# IfcProject, ОРИОН ZSK-50074
Classification: Классификатор строительных ресурсов (КСР)

# IfcFurnishingElement: Оборудование благоустройства, ZSK-50074 Тематический игровой комплекс «Дикий Запад»
In: Площадка
Description: Оборудование благоустройства. Тематический игровой комплекс «Дикий Запад»; Classification: 59.1.15.01-0532 Комплекс игровой (Классификатор строительных ресурсов (КСР))
Pset_ManufacturerTypeInformation - Manufacturer: Завод современных конструкций (ЗСК) · ООО «ПКФ «ОРИОН» · зск.рф · sales@zavod-orion.ru · 8 (351) 214-80-80; ModelLabel: ZSK-50074; ModelReference: Тематический игровой комплекс «Дикий Запад»; ProductionYear: 2026; ArticleNumber: ZSK-50074
ORION_Изделие - Артикул: ZSK-50074; Артикул прежний: SD-50074; Наименование: Тематический игровой комплекс «Дикий Запад»; Изготовитель: ООО «ПКФ «ОРИОН»; Марка: Завод современных конструкций (ЗСК); Город: Миасс, Челябинская область; Габариты: 11.9 x 7.0 м; Зона безопасности: 15.30 x 10.40 м; Высота свободного падения: 1.8 м; Возраст: для детей от 5 до 12 лет; Цена: 11 634 480 ₽; Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; Карточка изделия: https://зск.рф/catalog/themed/3001; Код КСИ: CPr>EDB080; Класс КСИ: Комплекс игровой; Коды КСР: 59.1.15.01-0532 … 59.1.15.01-0595
ADSK - ADSK_Наименование: Тематический игровой комплекс «Дикий Запад»; ADSK_Марка: ZSK-50074; ADSK_Код изделия: 59.1.15.01-0532; ADSK_Завод-изготовитель: ООО «ПКФ «ОРИОН»; ADSK_Единица измерения: шт.; ADSK_Количество: 1; ADSK_Обозначение: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ADSK_URL страницы изделия: https://зск.рф/catalog/themed/3001
ZSK_Благоустройство - ZSK_Возрастная_группа: для детей от 5 до 12 лет; ZSK_Зона_безопасности: 15.30 x 10.40 м; ZSK_Высота_свободного_падения: 1.8 м; ZSK_Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ZSK_Код_КСИ: CPr>EDB080; ZSK_Артикул_прежний: SD-50074
Qto_ORION - Длина: 11900 mm; Ширина: 7000 mm; Высота: 0 mm
